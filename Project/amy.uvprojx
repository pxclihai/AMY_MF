# Keil uVision project amy.uvprojx, settings and files
target STM32_Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: armchar3_77 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,BUILD_PROJECT=BOOT_HD
  c include: ..\App;..\FwLib\CM3;..\FwLib\STM32F10x_StdPeriph_Driver\inc;..\BSP;..\UserLib;..\Protocol;..\API;..\Fs\FATFS_V0.09\src;..\BSP\ETH\w5200_lib;..\BSP\ETH\w5200_lib\uip;..\BSP\ETH;..\qwl_net;..\Protocol_send;..\armchair;..\mofangSDK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../App/: main.c stm32f10x_it.c config.h moduleSelect.h
  group Fwlib
    ../FwLib/: STM32F10x_lib_HD.lib
    ../FwLib/CM3/: startup_stm32f10x_hd.s
  group UserLib
    ../UserLib/BasicFunc/: BasicFunc.c
  group data
    ../UserLib/data/: data.c data.h
  group Timer
    ../UserLib/LowPrecisionTime/: LowPrcisionTime.c
  group API
    ../API/: api.c api.h
  group BSP
    ../BSP/WatchDog/: WatchDog.c
    ../BSP/IAP/: IAP.c
    ../BSP/USART/: USART.c
    ../BSP/iap_updata/: iap_updata.c
    ../BSP/LED/: LED.c
    ../BSP/GPIO/: GpioMap.c GpioMap.h
    ../BSP/CESHI/: CESHI.C
    ../BSP/SpiFlash/: Spi_Flash.c
  group Protocol
    ../Protocol/: Protocol.c ProtocolRecCallBack.c Protocol_Debug.c Protocol_wcdma.c Protocol_MSG.c
  group PostProDa
    ../Protocol/PostProDa/: PostProDa.c Uploading_Pro.c
  group DownLoad
    ../Protocol/DownLoad/: DownLoad.c DownLoad_Pro.c
  group doc
    ../doc/: ReadMe.txt
  group qwl_net
    ../qwl_net/: qwl_net.c
    ../qwl_net/cdma/: cdma.c
    ../qwl_net/NBLOT/: nblot.c
    ../qwl_net/gsm/: M6312.c
    ../qwl_net/g510/: g510.c
  group Protocol_send
    ../Protocol_send/: Protocol_send.c
  group armchair
    ../armchair/: armchair.c
    ../armchair/TM1618/: TM1618.c
    ../armchair/433_2x1278/: 2x1278.c
    ../armchair/amy_net/: amy_net.c
    ../armchair/flash/: flash.c
    ../armchair/post_protocol/: post_protocol.c
    ../armchair/algorithm/: algorithm.c
  group MF_SDK
    ../mofangSDK/: PlugSdk.c Protool.c MF_Common.c
